# IAR project Ac_SL.ewp, settings and files
configuration STM32F4xx-MEMSMIC1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE; USE_STM32F4XX_NUCLEO; USE_USB_FS; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\AUDIO\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-CCA02M1; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Middlewares\ST\STM32_Audio\Addons\PDM; ..\..\..\..\..\..\Middlewares\ST\STCmdP\inc; ..\..\..\..\..\..\Middlewares\ST\STM32_AcousticSL_Library\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Ac_SL.bin
  ILINK.IlinkOutputFile: Ac_SL.out
  ILINK.IlinkIcfFile: Ac_SL.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f401xe.s
  group Application/User
    ../../Src/: audio_application.c cube_hal_f4.c main.c stm32xx_it.c usbd_audio_if.c usbd_conf_f4.c usbd_desc.c
  group Doc
    ../../: readme.txt
  group Middlewares/Drivers/BSP/STM32F4xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Middlewares/Drivers/BSP/X-NUCLEO-CCA02M1
    ../../../../../../Drivers/BSP/X-NUCLEO-CCA02M1/: x_nucleo_cca02m1_audio_f4.c
  group Middlewares/Drivers/CMSIS
    ../../Src/: system_stm32f4xx.c
  group Middlewares/Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_usb.c
  group Middlewares/ST/STM32_Audio/PDM
    ../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM4_IAR.a
  group Middlewares/ST/STM32_Audio/SOURCE LOCALIZATION
    ../../../../../../Middlewares/ST/STM32_AcousticSL_Library/Lib/: acoustic_SL_CM4F_IAR_ot.a
  group Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO/Src/: usbd_audio_in.c
  group Middlewares/ST/STM32_USB_Device_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
